
# Ensure all extra UART overlays are installed
RPI_KERNEL_DEVICETREE_OVERLAYS:append = " overlays/uart3.dtbo"

